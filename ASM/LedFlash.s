	AREA PROGRAM, CODE, READONLY	;NAME THIS BLOCK OF CODE
	ENTRY							;	 MAKE FIRST INSTRUCTION TO EXECUTE
START
	LDR R0,PINSEL0					; LOAD PINSEL0 VALUE IN R0
	LDR R1,=0X1						;LOAD CONSTANT VALUE IN R1
	STR R1,[R0]						;STORE FROM R1 TO ADDRES IN R0
	LDR R0,IO0DIR 					;LOAD IODIR VALUE IN R0
	LDR R1,OUTPUT					;LOAD OUTPUT VALUE IN R1
	STR R1,[R0]						;STORE FROM R1 TO ADDRESS IN R0
AGAIN
	LDR R2,=0X07					;LOAD CONSTANT VALUE IN R3
	LDR R0,IO0CLR					;LOAD IOCLR VALUE IN R0
	LDR R1,=0XFF					;
	STR R1,[R0]						;STORE FROM R1 TO ADDRESS IN R0
	BL DELAY						;CALL DELAY SUBROUTINE
	LDR R0,IO0SET					;LOAD IOSET VALUE IN R0
	LDR R1,=0XFF
	STR R1,[R0]						;STORE FROM R1 TO ADDRESS IN R0
	BL DELAY						;CALL DELAY SUBROUTINE
	BL AGAIN

DELAY
	LDR R2,=0X05					;
	
CONTINUEDELAY
	SUB R2,R2,#0X01					;SUBSTRACT REGISTER (R2=R2-0X01)
	CMP R2,#0						;SUBSTRACT THE VALUES R2 AND CONSTANT DATA
	BNE	CONTINUEDELAY
	BX LR
	
;/*	DEFINE THE VALUES TO WITH MACRO*/
OUTPUT
	DCD 0XFFFFFFFF

IO0DIR
	DCD 0XE0028008
		
IO0SET
	DCD	0XE0028004
		
IO0CLR
	DCD	0XE002800C
		
PINSEL0
	DCD 0XE002C000
		
	END