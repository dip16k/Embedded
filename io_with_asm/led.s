	AREA PROGRAM,CODE,READONLY			; NAME OF THIS BLOCK OF CODE
		
	ENTRY													; MAKE FIRST INSTRUCTION TO EXECUTE
	
START							
								
	LDR R0,PINSEL0								; LOAD PINSEL0 VALUE IN R0
	
	LDR R1,=0X0										; LOAD CONST VALLUE IN R1
	
	STR R1,[R0]										; STORE FROM R1 TO ADDRESS IN R0
	
	LDR R0,IO0DIR									; LOAD IODIR VALUE IN R0
	
	LDR R1,OUTPUT									; LOAD OUTPUT VALUE IN R1
	
	STR R1,[R0]										; STORE FROM R1 TO ADDRESS IN R0
	
AGAIN

	LDR R3,=0X7										; LOAD CONST VALUE IN R3
	
	LDR R0,IO0CLR									; LOAD IO0CLR VALLUE IN R0
	
	LDR R1,=0X000000FF						; LOAD CONST VALUE IN R1
	
	STR R1,[R0]										; STORE R1 TO ADDRESS IN R0
	
	BL DELAY											; CALL DELAY SUBROUTINE
	
	LDR R0,IO0SET									; LOAD IO SET VALUE IN R0
	
	LDR R1,=0X000000FF						; LOAD CONST VALUE IN R1
	
	STR R1,[R0]										; STORE R1 TO ADDRESS IN R0
	
	BL DELAY											; CALL DELAY SUBROUTIN
	
	BL AGAIN											; FOR INFINITE LOOP
	

DELAY
	
	LDR R2,=0X3600								; LOAD CONST VALUE IN R2
	
CONTINUEDELAY

	SUB R2,R2,#0X1								; SUBSTRACT REGISTER (R2=R2-0X01)
	
	CMP R2,#0											; COMPARE THE VALUES R2 AND CONST DATA
	
	BNE CONTINUEDELAY							; BRANCH IF NOT EQUAL JUMP TO LABEL
	
	BX LR													; BRANCH TO LR (LINK REGISTER)
	
;	DEFINE THE VALUES TO WITH MACRO
OUTPUT
	DCD 0XFFFFFFFF
	
IO0DIR
	DCD 0XE0028008
	
IO0SET
	DCD 0XE0028004
		
IO0CLR
	DCD 0XE002800C
		
PINSEL0
	DCD 0XE002C000
		
	END